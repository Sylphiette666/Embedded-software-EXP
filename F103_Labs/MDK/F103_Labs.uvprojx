# Keil uVision project F103_Labs.uvprojx, settings and files
target 01_Platform (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: 01_Platform +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: ..\App;..\Vendor\CMSIS5_Core;..\Vendor\Device\Include;..\Vendor\StdPeriph_Driver\inc
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
  group Experiments
    ../Labs/01_Platform/: main.c
    ../Labs/02_Register/: main.c
    ../Labs/03_StdPeriph/: main.c
    ../Labs/04_Keys/: main.c
    ../Labs/05_EXTI/: main.c
    ../Labs/06_USART/: main.c
    ../Labs/07_SysTick/: main.c
    ../Labs/08_Application/: main.c
  group Board drivers
    ../App/: platform.c platform.h stm32f10x_conf.h system_lab.c
  group STM32 Standard Peripheral Library
    ../Vendor/StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c misc.c
  group Startup
    ../Vendor/Device/Source/: startup_stm32f10x_md.s
  group Experiment 8 OLED
    ../Labs/08_Application/: oled.c oled.h oled_font.h
target 02_Register (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: 02_Register +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
target 03_StdPeriph (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: 03_StdPeriph +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
target 04_Keys (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: 04_Keys +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
target 05_EXTI (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: 05_EXTI +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
target 06_USART (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: 06_USART +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
target 07_SysTick (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: 07_SysTick +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
target 08_Application (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: 08_Application +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: -Wall -Wextra
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --entry=Reset_Handler
